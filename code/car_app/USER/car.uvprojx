# Keil uVision project car.uvprojx, settings and files
target CAR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAR +hex
  AfterMake: E:\MySoftware\Keil_ARM\ARM\ARMCC\bin\fromelf.exe "..\OBJ\car.axf" --bin --output "..\ccar.bin"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\inc;..\MALLOC;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\FWLIB\inc;..\HARDWARE\MPL\driver\eMPL;..\HARDWARE\MPL\driver\include;..\HARDWARE\MPL\driver\stm32L;..\HARDWARE\MPL\eMPL-hal;..\HARDWARE\MPL\mllite;..\HARDWARE\MPL\mpl
  memory RVCT4: ROM 0x800c000 size 0x73000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ../HARDWARE/src/: PESensor_Track.c
  group HARDWARE
    ../HARDWARE/src/: adc.c key.c led.c mpu9250.c myiic.c pwm.c rtc.c sdio_sdcard.c spi.c stmflash.c tft_display.c touch.c w25qxx.c beep.c timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group README
    ../: readme.txt
  group MPL
    ../HARDWARE/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPL/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPL/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPL/mpl/: libmpllib.lib
